PR = "r1"

require dejagnu_${PV}.bb
S = "${WORKDIR}/dejagnu-${PV}"
inherit native

