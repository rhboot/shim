require ocf-linux.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "3e68afaf6a76dfdab79540fbd6b0cbb3"
SRC_URI[sha256sum] = "5113609d2c2c43fde962bec1238fe5a81211a751ebb0337b54a9804d40cfef53"
